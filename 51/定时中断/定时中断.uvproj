# Keil uVision project 定时中断.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: 定时中断 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER\time
  group Source Group 1
    ./: STARTUP.A51 main.c 51_time.c
